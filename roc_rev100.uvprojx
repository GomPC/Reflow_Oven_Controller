# Keil uVision project roc_rev100.uvprojx, settings and files
target ROC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: roc_rev100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Lib\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
  group Src
    ./Startup/: system_stm32f10x.c
    ./Src/: main.c timer.c extio.c comm.c
  group Inc
    ./Inc/: main.h stm32f10x_conf.h system_stm32f10x.h timer.h extio.h comm.h
  group Lib_Inc
    ./Lib/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_usart.h misc.h stm32f10x_adc.h stm32f10x_flash.h
  group Lib_Src
    ./Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_flash.c
